# IAR project STM8S_USB_TO_IO_V100.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\library\src; ..\library\inc; ..\User\inc; ..\User\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_USB_TO_IO_V100.hex
  ILINK.IlinkOutputFile: STM8S_USB_TO_IO_V100.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Source
    ../User/src/: gpio.c main.c uart.c
  group STM8S_Driver
    ../library/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim4.c stm8s_uart1.c
