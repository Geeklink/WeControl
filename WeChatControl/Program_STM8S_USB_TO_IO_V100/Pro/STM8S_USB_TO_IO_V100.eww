<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S_USB_TO_IO_V100.ewp</path>
  </project>
  <batchBuild/>
</workspace>


